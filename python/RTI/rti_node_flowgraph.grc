options:
  parameters:
    author: OmerKarp
    copyright: OmerKarp
    generate_options: no_gui
    id: rti_node_flowgraph
    output_language: python
    title: rti_node_flowgraph
  states: {}

blocks:
- name: Rx_gain
  id: variable
  parameters:
    value: '35'
  states: {}
- name: Tx_gain
  id: variable
  parameters:
    value: '45'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: node_id
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: scheduler_port
  id: variable
  parameters:
    value: '"9001"'
  states: {}
- name: server_ip
  id: variable
  parameters:
    value: '"127.0.0.1"'
  states: {}
- name: server_port
  id: variable
  parameters:
    value: '9000'
  states: {}
- name: RTI_rssi_sender_0
  id: RTI_rssi_sender
  parameters:
    node_id: node_id
    port: server_port
    server_ip: server_ip
  states: {}
- name: RTI_tx_controller_0
  id: RTI_tx_controller
  parameters:
    node_id: node_id
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '4096'
    max_iter: '4000'
    scale: 1/4096
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.01'
    seed: '0'
    taps: '1.0'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: scheduler_port
    type: UDP_SERVER
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: Tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: Rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [RTI_tx_controller_0, '0', blocks_multiply_xx_0, '1']
- [RTI_tx_controller_0, ctrl, RTI_rssi_sender_0, ctrl]
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', RTI_rssi_sender_0, '0']
- [blocks_multiply_xx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [channels_channel_model_0, '0', blocks_complex_to_mag_squared_0, '0']
- [network_socket_pdu_0, pdus, RTI_tx_controller_0, in]
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
