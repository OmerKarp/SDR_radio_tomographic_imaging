options:
  parameters:
    author: OmerKarp
    copyright: OmerKarp
    generate_options: no_gui
    id: rti_node_flowgraph
    output_language: python
    title: rti_node_flowgraph
  states: {}

blocks:
- name: Rx_gain
  id: variable
  parameters:
    value: '35'
  states: {}
- name: Tx_gain
  id: variable
  parameters:
    value: '45'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: node_id
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: scheduler_port
  id: variable
  parameters:
    value: '"9001"'
  states: {}
- name: server_ip
  id: variable
  parameters:
    value: '"127.0.0.1"'
  states: {}
- name: server_port
  id: variable
  parameters:
    value: '9000'
  states: {}
- name: RTI_rssi_sender_0
  id: RTI_rssi_sender
  parameters:
    node_id: node_id
    port: server_port
    server_ip: server_ip
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '4096'
    max_iter: '4000'
    scale: 1/4096
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.01'
    seed: '0'
    taps: '1.0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import json
      from gnuradio import gr
      import numpy as np

      class blk(gr.sync_block):
          def __init__(self, node_id=1):
              gr.sync_block.__init__(self,
                  name="tx_controller",
                  in_sig=None,
                  out_sig=[np.complex64])

              # -----------------------------
              # PARAMETERS
              # -----------------------------
              self.node_id = int(node_id)

              # -----------------------------
              # MESSAGE INPUT (GRAY)
              # -----------------------------
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              # -----------------------------
              # MESSAGE OUTPUT (GRAY)
              # -----------------------------
              self.message_port_register_out(pmt.intern("ctrl"))

              # Internal state
              self.tx_enable = False
              self.tx_node = None
              self.frame_id = None
          
          def work(self, input_items, output_items):
              out = output_items[0]

              value = 1.0 + 0j if self.tx_enable else 0.0 + 0j
              out[:] = value
              
              return len(out)

          # -----------------------------
          # MESSAGE HANDLER
          # -----------------------------
          def handle_msg(self, msg):
              try:
                  # Extract payload from PDU
                  payload = pmt.cdr(msg)
                  payload_bytes = pmt.to_python(payload)

                  # Decode JSON
                  json_str = bytes(payload_bytes).decode('utf-8')
                  data = json.loads(json_str)

                  # Extract scheduler info
                  self.tx_node = int(data.get("tx_node", -1))
                  self.frame_id = int(data.get("frame_id", -1))

                  # -----------------------------
                  # CONTROL LOGIC
                  # -----------------------------
                  self.tx_enable = (self.tx_node == self.node_id)

                  print(f"[NODE {self.node_id}] "
                        f"tx_node={self.tx_node}, "
                        f"frame_id={self.frame_id}, "
                        f"tx_enable={self.tx_enable}")

                  # -----------------------------
                  # OUTPUT CONTROL MESSAGE
                  # -----------------------------
                  ctrl_dict = {
                      "tx_enable": self.tx_enable,
                      "tx_node": self.tx_node,
                      "frame_id": self.frame_id
                  }
                  ctrl_pmt = pmt.to_pmt(ctrl_dict)
                  msg_out = pmt.cons(pmt.PMT_NIL, ctrl_pmt)

                  self.message_port_pub(pmt.intern("ctrl"), msg_out)

              except Exception as e:
                  print(f"[TX_CTRL ERROR] {e}")
    node_id: node_id
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: scheduler_port
    type: UDP_SERVER
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: Tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: Rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', RTI_rssi_sender_0, '0']
- [blocks_multiply_xx_0, '0', blocks_null_sink_0, '0']
- [blocks_multiply_xx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [channels_channel_model_0, '0', blocks_complex_to_mag_squared_0, '0']
- [epy_block_0, '0', blocks_multiply_xx_0, '1']
- [epy_block_0, ctrl, RTI_rssi_sender_0, ctrl]
- [network_socket_pdu_0, pdus, epy_block_0, in]
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
